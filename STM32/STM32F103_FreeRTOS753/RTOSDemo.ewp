# IAR project RTOSDemo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xE ST STM32F103xE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: IAR_ARM_CM3
  ICCARM.CCDiagSuppress: Pa082, pe191
  ICCARM.CCIncludePath2: .; STM32F10x_StdPeriph_Lib_V3.5.0\Libraries\STM32F10x_StdPeriph_Driver\inc; Source\include; Common\include; CMSIS; user_task; test_task
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: .
  OBJCOPY.OOCOutputFile: RTOSDemo.srec
  ILINK.IlinkOutputFile: RTOSDemo.out
  ILINK.IlinkIcfFile: CMSIS\stm32f103xE.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    CMSIS/: startup_stm32f10x_hd.s system_stm32f10x.c
  group Demo files
    Common/Minimal/: BlockQ.c blocktim.c comtest.c death.c flash.c integer.c PollQ.c semtest.c
    ./: main.c Timer.c timertest.c
    ParTest/: ParTest.c
    CMSIS/: stm32f10x_it.c
    test_task/: task_test.c
  group FreeRTOS files
    Common/: heap_2.c port.c portasm.s
    Source/: list.c queue.c tasks.c
  group ST Library
    STM32F10x_StdPeriph_Lib_V3.5.0/Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group User app
    user_task/: hardware_init.c serial_init.c
